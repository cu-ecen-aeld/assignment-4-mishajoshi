## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Builds and installs scull and misc kernel modules from ldd3.
```
